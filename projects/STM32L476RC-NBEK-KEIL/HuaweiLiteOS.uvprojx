# Keil uVision project HuaweiLiteOS.uvprojx, settings and files
target HuaweiLiteOS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L476RCTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: HuaweiLiteOS
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: LOS_STM32L476xx,USE_HAL_DRIVER,STM32L476xx,UART_DBG,xLOS_KEY_EN,xLOS_LED_EN,xLOS_SHT2x_EN,xLOS_LUX_EN,xLOS_LIGHT_EN,xLOS_GPS_EN,LOS_NBIOT_EN
  c misc: --c99 --diag_suppress=177
  c include: ..\..\kernel\base\include;..\..\kernel\include;..\..\kernel\cpu\arm\cortex-m4;..\..\kernel\config;..\..\kernel\cmsis;..\..\kernel\link\keil;..\..\platform\STM32L476RC_NBEK;..\..\platform\STM32L476RC_NBEK\Inc;..\..\platform\STM32L476RC_NBEK\Display;..\..\platform\STM32L476RC_NBEK\NBxxModule;..\..\platform\STM32L476RC_NBEK\GpsParse;..\..\platform\STM32L476RC_NBEK\UART_DMA_CFG;..\..\platform\STM32L476RC_NBEK\UART_IT_CFG;..\..\example\include;..\..\platform\STM32L476RC_NBEK\Drivers\STM32L4xx_HAL_Driver\Inc;..\..\platform\STM32L476RC_NBEK\Drivers\STM32L4xx_HAL_Driver\Inc\Legacy;..\..\platform\STM32L476RC_NBEK\Drivers\CMSIS\Include;..\..\platform\STM32L476RC_NBEK\Drivers\CMSIS\Device\ST\STM32L4xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  scatter file: ..\..\platform\STM32L476RC_NBEK\STM32L476RC-LiteOS.sct
  group kernel
    ../../kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../../kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../../kernel/base/mem/: los_membox.c los_memory.c los_memstat.c los_multipledlinkhead.c
    ../../kernel/base/misc/: los_misc.c
  group cpu/m4
    ../../kernel/cpu/arm/cortex-m4/: los_hw.c los_hw_tick.c los_hwi.c los_dispatch_keil.s
  group config
    ../../kernel/config/: los_config.c
  group cmisis
    ../../kernel/cmsis/: cmsis_liteos.c
  group platform/STM32L476RC
    ../../platform/STM32L476RC_NBEK/: stm32l4xx_nbek.c los_bsp_adapter.c los_bsp_key.c los_bsp_led.c los_bsp_uart.c los_bsp_lcd.c los_bsp_nbuart.c los_bsp_timer.c los_bsp_nben.c los_bsp_sht2x.c los_bsp_lux.c los_bsp_pwm.c los_bsp_gps.c
    ../../platform/STM32L476RC_NBEK/Src/: stm32l4xx_it.c
  group platform/STM32L476RC/Driver
    ../../platform/STM32L476RC_NBEK/Src/: gpio.c usart.c spi.c dma.c i2c.c adc.c lptim.c
  group platform/STM32L476RC/Display
    ../../platform/STM32L476RC_NBEK/Display/: Display.c Display_cfg.c DisplayTFT128.c LCDDogm1286_util.c TFT128.c
  group platform/STM32L476RC/NBxx
    ../../platform/STM32L476RC_NBEK/NBxxModule/: NB_BC95.c NB_Board.c NB_Board_Cfg.c
  group platform/STM32L476RC/GpsParse
    ../../platform/STM32L476RC_NBEK/GpsParse/: gps_l70_r.c gps_board_Cfg.c
  group platform/STM32L476RC/UartDma
    ../../platform/STM32L476RC_NBEK/UART_DMA_CFG/: _dma_cfg.c
  group platform/STM32L476RC/UartIT
    ../../platform/STM32L476RC_NBEK/UART_IT_CFG/: hal_uart_isr.c
  group example
    ../../example/api/: los_api_dynamic_mem.c los_api_event.c los_api_interrupt.c los_api_list.c los_api_msgqueue.c los_api_mutex.c los_api_sem.c los_api_static_mem.c los_api_systick.c los_api_task.c los_api_timer.c los_cmsis_main.c los_demo_entry.c los_inspect_entry.c los_nbiot_entry.c los_led_entry.c los_key_entry.c los_sht2x_entry.c los_lux_entry.c los_light_entry.c los_gps_entry.c
  group startup
    ../../platform/STM32L476RC_NBEK/: los_startup_keil.s
  group user
    ../../user/: main.c
  group Driver/CMSIS
    ../../platform/STM32L476RC_NBEK/Drivers/CMSIS/Device/ST/STM32L4xx/Source/Templates/: system_stm32l4xx.c
  group Driver/STM32L4xx_hal_driver
    ../../platform/STM32L476RC_NBEK/Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_can.c stm32l4xx_hal_comp.c stm32l4xx_hal_cortex.c stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_cryp.c stm32l4xx_hal_cryp_ex.c stm32l4xx_hal_dac.c stm32l4xx_hal_dac_ex.c stm32l4xx_hal_dcmi.c stm32l4xx_hal_dfsdm.c stm32l4xx_hal_dfsdm_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_dma2d.c stm32l4xx_hal_dsi.c stm32l4xx_hal_firewall.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gfxmmu.c stm32l4xx_hal_gpio.c stm32l4xx_hal_hash.c stm32l4xx_hal_hash_ex.c stm32l4xx_hal_hcd.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_irda.c stm32l4xx_hal_iwdg.c stm32l4xx_hal_lcd.c stm32l4xx_hal_lptim.c stm32l4xx_hal_ltdc.c stm32l4xx_hal_ltdc_ex.c stm32l4xx_hal_nand.c stm32l4xx_hal_nor.c stm32l4xx_hal_opamp.c stm32l4xx_hal_opamp_ex.c stm32l4xx_hal_ospi.c stm32l4xx_hal_pcd.c stm32l4xx_hal_pcd_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_qspi.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rng.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_sai.c stm32l4xx_hal_sai_ex.c stm32l4xx_hal_sd.c stm32l4xx_hal_sd_ex.c stm32l4xx_hal_smartcard.c stm32l4xx_hal_smartcard_ex.c stm32l4xx_hal_smbus.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_sram.c stm32l4xx_hal_swpmi.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_tsc.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_usart.c stm32l4xx_hal_usart_ex.c stm32l4xx_hal_wwdg.c
